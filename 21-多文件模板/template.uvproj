# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\public;.\aap\key;.\aap\smg
  group app
    ./aap/key/: key.c key.h
    ./aap/smg/: smg.c smg.h
  group user
    ./user/: main.c
  group public
    ./public/: public.c public.h
